<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>FLASH</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>RAM</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Settings</name>
    <group>
      <name>Link</name>
      <file>
        <name>$PROJ_DIR$\src\Settings\Link\Pflash.icf</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Settings\Link\Ram.icf</name>
      </file>
    </group>
    <group>
      <name>Start</name>
      <file>
        <name>$PROJ_DIR$\src\Settings\Start_up\crt0.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Settings\Start_up\start.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Sources</name>
    <group>
      <name>App</name>
      <file>
        <name>$PROJ_DIR$\src\Sources\App\include.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Sources\App\isr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Sources\App\main.c</name>
      </file>
    </group>
    <group>
      <name>Cpu</name>
      <file>
        <name>$PROJ_DIR$\src\Sources\Cpu\common.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Sources\Cpu\common.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Sources\Cpu\MK60N512VMD100.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Sources\Cpu\vectors.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Sources\Cpu\vectors.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Sources\Cpu\wdog.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Sources\Cpu\wdog.h</name>
      </file>
    </group>
    <group>
      <name>Drivers</name>
      <file>
        <name>$PROJ_DIR$\src\Sources\Drivers\adc\adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Sources\Drivers\delay\delay.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Sources\Drivers\dma\dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Sources\Drivers\FTM\FTM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Sources\Drivers\gpio\gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Sources\Drivers\mcg\mcg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Sources\Drivers\oled\oled.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Sources\Drivers\PIT\PIT.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Sources\Drivers\uart\uart.c</name>
      </file>
    </group>
  </group>
</project>


