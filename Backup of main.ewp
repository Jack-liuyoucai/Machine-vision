# IAR project Backup of main.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TWR_K60N512; DEBUG
  ICCARM.CCIncludePath2: src\Sources\Cpu; src\Sources\App; src\Sources\Drivers\adc; src\Sources\Drivers\delay; src\Sources\Drivers\FTM; src\Sources\Drivers\gpio; src\Sources\Drivers\lptmr; src\Sources\Drivers\mcg; src\Sources\Drivers\PIT; src\Sources\Drivers\uart; src\Sources\Drivers\oled; src\Sources\Drivers\spi
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: main.srec
  ILINK.IlinkOutputFile: main.out
  ILINK.IlinkIcfFile: src\Settings\Link\Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DX256xxx10 Freescale MK60DX256xxx10
  ILINK.IlinkIcfFile: src\Settings\Link\Ram.icf
  group Settings/Link
    src/Settings/Link/: Pflash.icf Ram.icf
  group Settings/Start
    src/Settings/Start_up/: crt0.s start.c
  group Sources/App
    src/Sources/App/: include.h isr.h main.c
  group Sources/Cpu
    src/Sources/Cpu/: common.c common.h MK60N512VMD100.h vectors.c vectors.h wdog.c wdog.h
  group Sources/Drivers
    src/Sources/Drivers/adc/: adc.c
    src/Sources/Drivers/delay/: delay.c
    src/Sources/Drivers/dma/: dma.c
    src/Sources/Drivers/FTM/: FTM.c
    src/Sources/Drivers/gpio/: gpio.c
    src/Sources/Drivers/mcg/: mcg.c
    src/Sources/Drivers/oled/: oled.c
    src/Sources/Drivers/PIT/: PIT.c
    src/Sources/Drivers/uart/: uart.c
